# IAR project stm8s_reg_template_20180110.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: code\user\inc; code\lib\MyRegLibrary\inc; code\middleware\inc; code\vendor\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8s_reg_template_20180110.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group lib/reg
    code/lib/MyRegLibrary/scr/: stm8s_clock.c stm8s_tim4.c
  group middleware
    code/middleware/src/: mid_adder_subtractor.c mid_key.c parm_check.c
  group readme
    code/readme/: abbreviation.txt usage.txt
  group user/app
    code/user/src/: bsp.c key_app.c key_cfg.c key_hardware.c KeyDeal.c KeyDriver.c KeyDriverConfig.c KeyDriverHardware.c main.c stm8s_it.c SubFunction.c timer.c
