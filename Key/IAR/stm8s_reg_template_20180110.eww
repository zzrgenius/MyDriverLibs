<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\stm8s_reg_template_20180110.ewp</path>
  </project>
  <batchBuild/>
</workspace>


